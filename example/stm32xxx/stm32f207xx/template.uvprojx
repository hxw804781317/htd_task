# Keil uVision project template.uvprojx, settings and files
target htd_stm32f2xx (ARM-ADS)
  device: STM32F207VCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f207xx +hex
  BeforeMake: ..\..\..\tools\keil_scripts\before_build_common.bat
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tools\keil_scripts\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat  @L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
