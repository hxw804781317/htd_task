# Keil uVision project project.uvprojx, settings and files
target stm32f401xx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f401 +hex
  BeforeMake: ..\..\..\tools\keil_scripts\before_build_common.bat
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tools\keil_scripts\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat  @L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER, STM32F401xC, USE_HAL_DRIVER
  c include: .;applications;..\..\..\components;..\..\..\components\htd_console;..\..\..\device;..\..\..\device\drv_stm32fxxx;..\..\..\device\drv_stm32fxxx\stm32f4;..\..\..\external;..\..\..\external\segger_rtt;..\..\..;..\..\..\task;..\..\..\task\common;..\..\..\task\memheap;..\..\..\peripherals;..\..\..\peripherals\norflash;..\..\..\peripherals\norflash\dev;..\..\..\peripherals\imu_6axis;..\..\..\peripherals\imu_6axis\dev;..\..\..\mcu_sdk\stm32fxxx;..\..\..\mcu_sdk\stm32fxxx\STM32F4xx_HAL\CMSIS\Device\ST\stm32f4xx\Include;..\..\..\mcu_sdk\stm32fxxx\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\mcu_sdk\stm32fxxx\STM32F4xx_HAL\CMSIS\Include;board
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: app_main.c
  group htd_console
    ../../../components/htd_console/: htd_console_process.c htd_console_port.c htd_console_history.c htd_console_printf_fmt.c
  group htd_device
    ../../../device/drv_stm32fxxx/: htd_drv_adc.c htd_drv_clock.c htd_drv_common.c htd_drv_crc.c htd_drv_dma.c htd_drv_gpio.c htd_drv_hash.c htd_drv_i2c_master.c htd_drv_pm.c htd_drv_rng.c htd_drv_rtc_v1.c htd_drv_rtc_v2.c htd_drv_spi_master.c htd_drv_uart.c htd_drv_wdt.c
    ../../../device/drv_stm32fxxx/stm32f4/: htd_drv_config.c htd_drv_inflash.c htd_drv_wkup.c
    ../../../device/: htd_dev_adc.c htd_dev_aes.c htd_dev_crc.c htd_dev_gpio.c htd_dev_hash.c htd_dev_i2cm.c htd_dev_inflash.c htd_dev_info.c htd_dev_pm.c htd_dev_rng.c htd_dev_rtc.c htd_dev_sdio.c htd_dev_segger_rtt.c htd_dev_serial.c htd_dev_spim.c htd_dev_timer.c htd_dev_timer_occ.c htd_dev_timer_pwm.c htd_dev_usbd.c htd_dev_wdt.c htd_device.c htd_sfw_aes128.c htd_sfw_crc.c htd_sfw_i2cm.c htd_sfw_md5.c htd_sfw_sha1.c htd_sfw_sha256.c htd_sfw_spim.c
  group htd_external
    ../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group htd_task
    ../../../task/common/: htd_base16.c htd_base32.c htd_base64.c htd_bitmap.c htd_fifo.c htd_log.c htd_printf_fmt.c htd_time.c htd_tlv.c
    ../../../task/: htd_task.c htd_task_freertos.c htd_task_fun_export.c htd_task_nos.c htd_task_nos_sch.c htd_task_port.c htd_task_sch.c htd_task_thread_sch.c htd_task_win32_sdl2.c
    ../../../task/memheap/: htd_memheap_ff.c htd_memheap_sram_dev.c
  group peripherals
    ../../../peripherals/norflash/dev/: drv_norflash_sff_parser.c drv_norflash_simulator.c drv_norflash_spi.c
    ../../../peripherals/norflash/: htd_dev_norflash.c
  group peripherals-6axis
    ../../../peripherals/imu_6axis/dev/: drv_6axis_mpu6050.c drv_6axis_simulate.c
    ../../../peripherals/imu_6axis/: htd_6axis_dev.c htd_6axis_process.c
  group stm32_sdk
    ../../../mcu_sdk/stm32fxxx/STM32F4xx_HAL/CMSIS/Device/ST/stm32f4xx/Source/Templates/: system_stm32f4xx.c
    ../../../mcu_sdk/stm32fxxx/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group stm32f4xx
    board/: startup_stm32f401xc.s app_board.c stm32f4xx_hal_msp.c stm32f4xx_it.c
software components: CMSIS:CORE 5.4.0
