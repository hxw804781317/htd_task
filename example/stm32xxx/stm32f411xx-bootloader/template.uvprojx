# Keil uVision project template.uvprojx, settings and files
target stm32f411xx-bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: stm32f411-bootloader +hex
  BeforeMake: ..\..\..\tools\keil_scripts\before_build_common.bat
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tools\keil_scripts\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat  @L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
