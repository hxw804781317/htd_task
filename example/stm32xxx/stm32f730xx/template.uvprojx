# Keil uVision project template.uvprojx, settings and files
target stm32f730xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F730V8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20010000,0x0002C000) IROM(0x08000000,0x00100000) IROM2(0x00200000,0x00100000) XRAM(0x2003C000,0x00004000) XRAM2(0x40024000,0x00001000) XRAM3(0x00000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: stm32f730 +hex
  BeforeMake: ..\..\..\tools\keil_scripts\before_build_common.bat
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tools\keil_scripts\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat  @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT7: RAM 0x40024000 size 0x1000
  memory RVCT8: RAM 0x0 size 0x4000
  memory RVCT9: RAM 0x20010000 size 0x30000
  scatter file: .\board\linker_scripts\link.sct
software components: CMSIS:CORE 5.4.0
